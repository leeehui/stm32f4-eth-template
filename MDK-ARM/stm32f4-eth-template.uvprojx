# Keil uVision project stm32f4-eth-template.uvprojx, settings and files
target stm32f4-eth-template (ARM-ADS)
  device: STM32F407VGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.2.0
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4")
  output: stm32f4-eth-template
  c flags: Optim=4 OneElfS=1 uC99=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F407xx
  c misc: --C99
  c include: ../Inc;../Middlewares/Third_Party/LwIP/src/include;../Middlewares/Third_Party/LwIP/system;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Middlewares/Third_Party/FreeRTOS/Source/include;../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS;../Middlewares/Third_Party/LwIP/src/include/lwip;../Middlewares/Third_Party/LwIP/src/include/lwip/apps;../Middlewares/Third_Party/LwIP/src/include/lwip/priv;../Middlewares/Third_Party/LwIP/src/include/lwip/prot;../Middlewares/Third_Party/LwIP/src/include/netif;../Middlewares/Third_Party/LwIP/src/include/netif/ppp;../Middlewares/Third_Party/LwIP/src/include/netif/ppp/polarssl;../Middlewares/Third_Party/LwIP/src/include/posix;../Middlewares/Third_Party/LwIP/src/include/posix/sys;../Middlewares/Third_Party/LwIP/system/arch;../Drivers/CMSIS/Include;..\Src\ws2812
  asm include: ..\Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  link misc: --diag_suppress=L6329
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/: queue.c list.c croutine.c tasks.c event_groups.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
  group Middlewares/LwIP
    ../Middlewares/Third_Party/LwIP/src/netif/ppp/: ccp.c demand.c magic.c eap.c ppp.c pppol2tp.c chap-md5.c multilink.c vj.c upap.c eui64.c chap_ms.c ecp.c mppe.c auth.c utils.c lcp.c pppos.c chap-new.c pppapi.c pppoe.c fsm.c ipv6cp.c ipcp.c pppcrypt.c
    ../Middlewares/Third_Party/LwIP/src/core/ipv6/: icmp6.c ip6_addr.c inet6.c dhcp6.c ethip6.c ip6.c mld6.c nd6.c ip6_frag.c
    ../Middlewares/Third_Party/LwIP/src/core/: tcp_in.c inet_chksum.c raw.c netif.c stats.c sys.c tcp_out.c timeouts.c udp.c memp.c dns.c init.c mem.c tcp.c ip.c def.c pbuf.c
    ../Middlewares/Third_Party/LwIP/src/core/ipv4/: autoip.c ip4.c etharp.c dhcp.c ip4_frag.c icmp.c igmp.c ip4_addr.c
    ../Middlewares/Third_Party/LwIP/src/api/: api_lib.c tcpip.c netifapi.c api_msg.c err.c sockets.c netbuf.c netdb.c
    ../Middlewares/Third_Party/LwIP/src/netif/ppp/polarssl/: des.c sha1.c md5.c arc4.c md4.c
    ../Middlewares/Third_Party/LwIP/system/OS/: sys_arch.c
    ../Middlewares/Third_Party/LwIP/src/netif/: ethernet.c lowpan6.c slipif.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_eth.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_cortex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_tim.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_uart.c
  group Drivers/CMSIS
    ../Src/: system_stm32f4xx.c
  group Application/MDK-ARM
    ./: startup_stm32f407xx.s
  group Application/User
    ../Src/: freertos.c stm32f4xx_hal_msp.c lwip.c main.c ethernetif.c stm32f4xx_it.c stm32f4xx_hal_timebase_TIM.c tcp_led_ctrl.c
    ../Src/ws2812/: light_ws2812_cortex.c
software components: CMSIS:CORE 4.1.0
